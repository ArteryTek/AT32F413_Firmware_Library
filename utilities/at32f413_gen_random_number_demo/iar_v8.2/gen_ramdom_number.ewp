# IAR project gen_ramdom_number.ewp, settings and files
configuration at_start_f403a (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\project\at32f413_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gen_ramdom_number.bin
  ILINK.IlinkOutputFile: gen_ramdom_number.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f407 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F407VGT7_v2 ArteryTek -AT32F407VGT7
  ICCARM.CCDefines: AT32F407VGT7; USE_STDPERIPH_DRIVER; AT_START_F407_V1
  group bsp
    ../../../project/at32f413_board/: at32f413_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f413.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../libraries/drivers/src/: at32f413_bpr.c at32f413_crm.c at32f413_gpio.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c random.c
