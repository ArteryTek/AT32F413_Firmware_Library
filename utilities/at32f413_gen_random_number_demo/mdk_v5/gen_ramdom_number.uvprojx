# Keil uVision project gen_ramdom_number.uvprojx, settings and files
target gen_ramdom_number (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gen_ramdom_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: ..\inc;..\..\..\project\at32f413_board;..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f413_clock.c at32f413_int.c random.c main.c
  group bsp
    ../../../project/at32f413_board/: at32f413_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f413_crm.c at32f413_rtc.c at32f413_usart.c at32f413_gpio.c at32f413_misc.c at32f413_bpr.c at32f413_pwc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group readme
    ../: readme.txt
