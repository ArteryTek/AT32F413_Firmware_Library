# Keil uVision project app_led4_toggle.uvprojx, settings and files
target app_led4_toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_led4_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: ..\inc;..\..\..\..\..\project\at32f413_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8006000 size 0x3a000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f413_clock.c at32f413_int.c hid_iap_user.c main.c
  group bsp
    ../../../../../project/at32f413_board/: at32f413_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f413_acc.c at32f413_crc.c at32f413_crm.c at32f413_usart.c at32f413_flash.c at32f413_gpio.c at32f413_misc.c at32f413_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
