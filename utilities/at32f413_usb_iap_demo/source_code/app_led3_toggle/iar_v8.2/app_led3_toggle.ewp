# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f413_board; ..\..\..\..\..\middlewares\usbd_class\hid_iap; ..\..\..\..\..\middlewares\usbd_drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F413xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f413_board/: at32f413_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f413.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f413_acc.c at32f413_crc.c at32f413_crm.c at32f413_flash.c at32f413_gpio.c at32f413_misc.c at32f413_usb.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32f413_clock.c at32f413_int.c hid_iap_user.c main.c
