# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\project\at32f413_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f413_clock.c at32f413_int.c flash.c iap.c usart.c tmr.c main.c
  group bsp
    ../../../../../project/at32f413_board/: at32f413_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f413_crm.c at32f413_flash.c at32f413_gpio.c at32f413_usart.c at32f413_tmr.c at32f413_misc.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group readme
    ../: readme.txt
