<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\extend_sram.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_16k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_32k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_64k</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
