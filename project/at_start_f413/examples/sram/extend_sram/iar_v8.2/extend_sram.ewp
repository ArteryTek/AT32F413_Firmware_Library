# IAR project extend_sram.ewp, settings and files
configuration extend_sram_64k (ARM)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1; EXTEND_SRAM=0x00
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32f413_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extend_sram.srec
  ILINK.IlinkOutputFile: extend_sram_64k.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration extend_sram_32k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1; EXTEND_SRAM=0x03
  ILINK.IlinkOutputFile: extend_sram_32k.out
configuration extend_sram_16k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1; EXTEND_SRAM=0x01
  ILINK.IlinkOutputFile: extend_sram_16k.out
  group bsp
    ../../../../../at32f413_board/: at32f413_board.c
  group cmsis
    ./: startup_at32f413_ext_ram.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f413_crm.c at32f413_flash.c at32f413_gpio.c at32f413_misc.c at32f413_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c
